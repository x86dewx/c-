# Keil uVision project Fire_F103ZE.uvprojx, settings and files
target ESP8266 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\SysTick;..\..\User\usart;..\..\User\Common;..\..\User\ESP8266;..\..\User\dht11;..\..\User\led;..\..\User\dwt_delay;..\..\User\mqtt;..\..\User\OLED;..\..\User\IrDa;..\..\User\HX711;..\..\User\RFID;..\..\User\sys;..\..\User\MAX485;..\..\User\timer;..\..\User\GPS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/led/: bsp_led.c bsp_key.c bsp_key.h
    ../../User/usart/: bsp_usart.c
    ../../User/OLED/: oled.c
    ../../User/MAX485/: exti.c exti.h
    ./: read.txt
    ../../User/timer/: timer.c timer.h
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266.h bsp_esp8266_test.c bsp_esp8266_test.h
    ../../User/GPS/: bsp_gps.c bsp_gps.h
  group DOC
    ../../Doc/: readme.txt
    ../../User/sys/: sys.c sys.h
  group COMM
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/Common/: Common.c
